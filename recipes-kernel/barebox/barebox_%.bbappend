FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://trim-conf.cfg"
